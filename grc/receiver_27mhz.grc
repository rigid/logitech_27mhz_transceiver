<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>100</value></param>
<param><key>threshold</key><value>5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_1</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>100</value></param>
<param><key>threshold</key><value>5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>25000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>center_freq</key><value>-25000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_bin_slicer_bb</key>
<param><key>id</key><value>logitech_27mhz_transceiver_bin_slicer_bb_0</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_bin_slicer_bb</key>
<param><key>id</key><value>logitech_27mhz_transceiver_bin_slicer_bb_1</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_packet_decoder</key>
<param><key>id</key><value>logitech_27mhz_transceiver_packet_decoder_0</value></param>
<param><key>access_code</key><value>11001100110011000000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>verbose</key><value>1</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_packet_decoder</key>
<param><key>id</key><value>logitech_27mhz_transceiver_packet_decoder_0_0</value></param>
<param><key>access_code</key><value>11001100110011000000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>verbose</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>8000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2</value></param>
<param><key>cutoff_freq</key><value>8000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>27120000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>logitech_27mhz_transceiver_bin_slicer_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_1</source_block_id><sink_block_id>logitech_27mhz_transceiver_bin_slicer_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>low_pass_filter_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_bin_slicer_bb_0</source_block_id><sink_block_id>logitech_27mhz_transceiver_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_bin_slicer_bb_1</source_block_id><sink_block_id>logitech_27mhz_transceiver_packet_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_packet_decoder_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_packet_decoder_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2</source_block_id><sink_block_id>analog_pwr_squelch_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
